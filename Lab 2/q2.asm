	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x40001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=N1
	LDR R1,[R0]
	LDR R3,=N2
	LDR R2,[R3]
UP	CMP R1,R2
	BEQ EXIT
	SUBHI R1,R2
	SUBLO R2,R1
	B UP
EXIT LDR R5,=HCF
	 STR R1,[R5]
	
	
STOP B STOP
N1 DCD 15
N2 DCD 5
	AREA data, DATA, READWRITE
HCF DCD 0
	END