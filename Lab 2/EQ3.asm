	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x40001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=N1
	LDR R1,[R0]
	LDR R3,=N2
	LDR R2,[R3]
	LDR R9,=N3
	LDR R8,[R9]
UP  CMP R2,R1
	BCC EXIT
	
	ADD R8,#1
	SUB R2,R1
	B UP
	
EXIT LDR R5,=QUO
	 STR R8,[R5]
	 LDR R6,=REM
	 STR R2,[R6]
STOP B STOP
N1 DCD 9
N2 DCD 43
N3 DCD 0
	AREA data,DATA,READWRITE
QUO DCD 0
REM DCD 0
	END
	