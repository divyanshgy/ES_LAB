	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x40001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=N1
	LDR R1,[R0]
	LDR R3,=N2
	LDR R2,[R3]
	MOV R4,#1
	MOV R5,#0
	MOV R6,#0
UP	
	MUL R5,R4,R1
	BL DIV
	CMP R6,#0
	BEQ LEAVE
	ADD R4,#1
	B UP
LEAVE 	
	LDR R7,=LCM
	STR R5,[R7]
STOP 
	B STOP
DIV
GO  
	CMP R5,R2
	BEQ EXIT
	SUBHI R5,R2
	SUBLO R2,R5
	B GO
EXIT 
	LDR R6,=REM
	STR R2,[R6]
	BX LR
N1 DCD 13
N2 DCD 4
	AREA data,DATA,READWRITE
LCM DCD 0
REM DCD 0
	END